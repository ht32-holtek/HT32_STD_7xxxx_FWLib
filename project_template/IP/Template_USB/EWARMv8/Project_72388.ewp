# IAR project Project_72388.ewp, settings and files
configuration HT32 (ARM, debug)
  General.OGChipSelectEditMenu: HT32F72388 Holtek HT32F72388
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F72388_SK; USE_HT32F72368_78_88; USE_MEM_HT32F72388
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F7xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F7xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=38; USE_LIBCFG_RAM_SIZE=0x10000
  OBJCOPY.OOCOutputFile: HT32.hex
  ILINK.IlinkOutputFile: HT32.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_ht32f7xxxx_01.c
  group Config
    ../: ht32_board_config.h _ht32_project_source.h ht32f7xxxx_conf.h ht32f7xxxx_01_usbdconf.h
    ./: ht32_op.c ht32_op2.c
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32f7xxxx_iar_01.s
  group Library
    ../../../../library/HT32F7xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f7xxxx_adc.c ht32f7xxxx_aes.c ht32f7xxxx_bftm.c ht32f7xxxx_can.c ht32f7xxxx_ckcu.c ht32f7xxxx_cmp.c ht32f7xxxx_crc.c ht32f7xxxx_dac.c ht32f7xxxx_div.c ht32f7xxxx_ebi.c ht32f7xxxx_exti.c ht32f7xxxx_flash.c ht32f7xxxx_gpio.c ht32f7xxxx_i2c.c ht32f7xxxx_i2s.c ht32f7xxxx_mctm.c ht32f7xxxx_pdma.c ht32f7xxxx_pwrcu.c ht32f7xxxx_ramecc.c ht32f7xxxx_rstcu.c ht32f7xxxx_rtc.c ht32f7xxxx_sci.c ht32f7xxxx_spi.c ht32f7xxxx_tm.c ht32f7xxxx_rng.c ht32f7xxxx_usart.c ht32f7xxxx_usbd.c ht32f7xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F7xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ../: ht32_usbd_class.c ht32_usbd_descriptor.c ht32f7xxxx_01_it.c main.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
