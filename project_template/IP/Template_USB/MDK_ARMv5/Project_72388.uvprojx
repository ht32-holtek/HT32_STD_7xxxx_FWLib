# Keil uVision project Project_72388.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F72388 Holtek
  pack: Holtek.HT32_DFP.1.0.80
  cpu: IROM(0x00000000-0x0007FDFF) IRAM(0x20000000-0x2000FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F72388_SK, USE_HT32F72368_78_88, USE_MEM_HT32F72388
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F7xxxx\Include;..\..\..\..\library\HT32F7xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=38, USE_LIBCFG_RAM_SIZE=0x10000
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f7xxxx_01_it.c ht32_usbd_class.c ht32_usbd_descriptor.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32f7xxxx_conf.h ht32f7xxxx_01_usbdconf.h
    ./: ht32_op.s ht32_op2.s HT32F7xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f7xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f7xxxx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F7xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f7xxxx_adc.c ht32f7xxxx_aes.c ht32f7xxxx_bftm.c ht32f7xxxx_can.c ht32f7xxxx_ckcu.c ht32f7xxxx_cmp.c ht32f7xxxx_crc.c ht32f7xxxx_dac.c ht32f7xxxx_div.c ht32f7xxxx_ebi.c ht32f7xxxx_exti.c ht32f7xxxx_flash.c ht32f7xxxx_gpio.c ht32f7xxxx_i2c.c ht32f7xxxx_i2s.c ht32f7xxxx_mctm.c ht32f7xxxx_pdma.c ht32f7xxxx_pwrcu.c ht32f7xxxx_ramecc.c ht32f7xxxx_rstcu.c ht32f7xxxx_rtc.c ht32f7xxxx_sci.c ht32f7xxxx_spi.c ht32f7xxxx_tm.c ht32f7xxxx_rng.c ht32f7xxxx_usart.c ht32f7xxxx_usbd.c ht32f7xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F7xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
software components: HT32 Stack Usage Analysis:HT32 Stack Usage Analysis 1.0.0
